# Keil uVision project iSO-STM32.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c misc: --gnu
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\string_op;..\..\User\print_string;..\..\User\oopc;..\..\User\heap;..\..\User\queue;..\..\User\xmodem;..\..\User\check_string
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h usart.c LED.c key.c main.c stream_in_out.c app_cfg.h
  group QUEUE
    ../../User/queue/: app_cfg.h queue.c queue.h
  group EVENT
    ../../User/event/: event.c event.h app_cfg.h
  group CRITICL
    ../../User/critical/: app_cfg.h critical.c critical.h
  group MAIL
    ../../User/mail/: app_cfg.h mail.c mail.h
  group XMODEM
    ../../User/xmodem/: app_cfg.h xmodem.c xmodem.h
  group PRINT_STRING
    ../../User/print_string/: app_cfg.h print_string.c print_string.h
  group CHECK_STRING
    ../../User/check_string/: app_cfg.h check_string.c check_string.h
  group CHECK_LIST
    ../../User/check_list/: app_cfg.h check_list.c check_list.h
  group MSG_MAP
    ../../User/msg_map/: msg_map.c msg_map.h app_cfg.h
